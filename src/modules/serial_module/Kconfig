## src/modules/serial_module/Kconfig
```kconfig
menuconfig MODULES_SERIAL_MODULE
	bool "serial_module"
	default n
	---help---
		Enable support for serial_module
```
